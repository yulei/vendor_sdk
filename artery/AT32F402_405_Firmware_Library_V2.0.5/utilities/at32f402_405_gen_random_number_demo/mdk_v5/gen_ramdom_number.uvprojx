# Keil uVision project gen_ramdom_number.uvprojx, settings and files
target at_start_f405 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gen_random_number +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1
  c include: ..\inc;..\..\..\project\at32f402_405_board;..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: main.c random.c at32f402_405_clock.c at32f402_405_int.c
  group bsp
    ../../../project/at32f402_405_board/: at32f402_405_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f402_405_crm.c at32f402_405_ertc.c at32f402_405_gpio.c at32f402_405_misc.c at32f402_405_usart.c at32f402_405_pwc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group readme
    ../: readme.txt
target at_start_f402 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F402RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.0
  cpu: as above
  output: gen_random_number +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F402RCT7,USE_STDPERIPH_DRIVER,AT_START_F402_V1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
