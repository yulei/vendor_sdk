# IAR project Project.ewp, settings and files
configuration GD32H73x_75x (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H73X_75X
  ICCARM.CCIncludePath2: ..\..\Utilities; ..; ..\..\Firmware\GD32H73x_75x_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32H73x_75x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32h73x_75x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32H73x_75x/Source/: system_gd32h73x_75x.c
  group Doc
    ../: readme.txt
  group GD32H73x_75x_EVAL
    ../../Utilities/: gd32h759i_eval.c
  group GD32H73x_75x_Peripherals
    ../../Firmware/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_adc.c gd32h73x_75x_can.c gd32h73x_75x_cau.c gd32h73x_75x_cau_aes.c gd32h73x_75x_cau_des.c gd32h73x_75x_cau_tdes.c gd32h73x_75x_cmp.c gd32h73x_75x_cpdm.c gd32h73x_75x_crc.c gd32h73x_75x_ctc.c gd32h73x_75x_dac.c gd32h73x_75x_dbg.c gd32h73x_75x_dci.c gd32h73x_75x_dma.c gd32h73x_75x_edout.c gd32h73x_75x_efuse.c gd32h73x_75x_exmc.c gd32h73x_75x_exti.c gd32h73x_75x_fac.c gd32h73x_75x_fmc.c gd32h73x_75x_fwdgt.c gd32h73x_75x_gpio.c gd32h73x_75x_hau.c gd32h73x_75x_hau_sha_md5.c gd32h73x_75x_hpdf.c gd32h73x_75x_hwsem.c gd32h73x_75x_i2c.c gd32h73x_75x_ipa.c gd32h73x_75x_lpdts.c gd32h73x_75x_mdio.c gd32h73x_75x_mdma.c gd32h73x_75x_misc.c gd32h73x_75x_ospi.c gd32h73x_75x_ospim.c gd32h73x_75x_pmu.c gd32h73x_75x_rameccmu.c gd32h73x_75x_rcu.c gd32h73x_75x_rspdif.c gd32h73x_75x_rtc.c gd32h73x_75x_rtdec.c gd32h73x_75x_sai.c gd32h73x_75x_sdio.c gd32h73x_75x_spi.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_tli.c gd32h73x_75x_tmu.c gd32h73x_75x_trigsel.c gd32h73x_75x_trng.c gd32h73x_75x_usart.c gd32h73x_75x_vref.c gd32h73x_75x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32H73x_75x/Source/IAR/: startup_gd32h73x_75x.s
