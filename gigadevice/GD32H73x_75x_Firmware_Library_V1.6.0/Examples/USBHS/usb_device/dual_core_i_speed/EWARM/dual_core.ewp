# IAR project dual_core.ewp, settings and files
configuration GD32H73x_75x_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H73X_75X; USE_USB_FS; USE_USBHS0; USE_USBHS1
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32H73x_75x\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\device\class\cdc\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\class\cdc; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\class\hid; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dual_core.srec
  ILINK.IlinkOutputFile: dual_core.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H73x_75x_USBHS (ARM, debug)
  as the first configuration, except:
  General.FPU2: 6
  ICCARM.CCDefines: GD32H73X_75X; USE_USB_HS; USE_USBHS0; USE_USBHS1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  group App
    ../src/: app.c custom_hid_itf.c gd32h73x_75x_it.c gd32h73x_75x_usb_hw.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/: system_gd32h73x_75x.c
  group Doc
    ../: readme.txt
  group GD32H73x_75x_EVAL
    ../../../../../Utilities/: gd32h759i_eval.c
  group GD32H73x_75x_Peripherals
    ../../../../../Firmware/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_exti.c gd32h73x_75x_gpio.c gd32h73x_75x_misc.c gd32h73x_75x_pmu.c gd32h73x_75x_rcu.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/IAR/: startup_gd32h73x_75x.s
  group USB_Class
    ../../../../../Firmware/GD32H73x_75x_usbhs_library/device/class/cdc/Source/: cdc_acm_core.c
    ../../../../../Firmware/GD32H73x_75x_usbhs_library/device/class/hid/Source/: custom_hid_core.c
  group USB_Device
    ../../../../../Firmware/GD32H73x_75x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32H73x_75x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
