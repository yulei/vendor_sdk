# IAR project usbh_hid.ewp, settings and files
configuration GD32H73x_75x_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: GD32H73X_75X; USE_USB_FS; USE_USBHS0; USE_LCD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32H73x_75x\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\host\class\hid\Include; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\class\hid; ..\..\..\..\..\Utilities; ..\..\..\..\..\Utilities\LCD_common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H73x_75x_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32H73X_75X; USE_USB_HS; USE_USBHS0; USE_LCD
configuration GD32H73x_75x_ULPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32H73X_75X; USE_USB_HS; USE_USBHS0; USE_ULPI_PHY
  group App
    ../src/: app.c gd32h73x_75x_it.c gd32h73x_75x_usb_hw.c gd32h73x_75x_usb_test.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/: system_gd32h73x_75x.c
  group Doc
    ../: readme.txt
  group GD32H73x_75x_EVAL
    ../src/: gd32h759i_eval.c
    ../../../../../Utilities/: gd32h759i_eval_exmc_sdram.c gd32h759i_lcd_eval.c
    ../../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group GD32H73x_75x_Peripherals
    ../../../../../Firmware/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_exmc.c gd32h73x_75x_exti.c gd32h73x_75x_gpio.c gd32h73x_75x_misc.c gd32h73x_75x_pmu.c gd32h73x_75x_rcu.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_tli.c gd32h73x_75x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/IAR/: startup_gd32h73x_75x.s
  group USB_Class
    ../../../../../Firmware/GD32H73x_75x_usbhs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Driver
    ../../../../../Firmware/GD32H73x_75x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32H73x_75x_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
