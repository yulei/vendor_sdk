# IAR project dual_role.ewp, settings and files
configuration GD32H73x_75x (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H73X_75X; USE_USB_FS; USE_USB_HS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Firmware\CMSIS\GD\GD32H73x_75x\Include; ..\..\..\..\Firmware\GD32H73x_75x_standard_peripheral\Include; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\driver\Include; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\device\core\Include; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\host\core\Include; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\device\class\hid\Include; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\host\class\msc\Include; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\common; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\class\hid; ..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\class\msc; ..\..\..\..\Utilities; ..\fat_fs\inc; ..\..\..\..\Utilities\LCD_common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dual_role.srec
  ILINK.IlinkOutputFile: dual_role.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c custom_hid_itf.c gd32h73x_75x_it.c gd32h73x_75x_usb_hw.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32h73x_75x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32H73x_75x_EVAL
    ../../../../Utilities/: gd32h759i_eval.c gd32h759i_eval_exmc_sdram.c gd32h759i_lcd_eval.c
    ../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group GD32H73x_75x_Peripherals
    ../../../../Firmware/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_exmc.c gd32h73x_75x_exti.c gd32h73x_75x_gpio.c gd32h73x_75x_misc.c gd32h73x_75x_pmu.c gd32h73x_75x_rcu.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_tli.c gd32h73x_75x_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/IAR/: startup_gd32h73x_75x.s
  group USB_Device
    ../../../../Firmware/GD32H73x_75x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../Firmware/GD32H73x_75x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usb_host.c drv_usbd_int.c drv_usbh_int.c
  group USB_Host
    ../../../../Firmware/GD32H73x_75x_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USBD_Class
    ../../../../Firmware/GD32H73x_75x_usbhs_library/device/class/hid/Source/: custom_hid_core.c
  group USBH_Class
    ../../../../Firmware/GD32H73x_75x_usbhs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
