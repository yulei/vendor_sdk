# Keil uVision project dual_role.uvprojx, settings and files
target usb_dual_role (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H73x_75x_DFP.1.2.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: dual_role +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_USB_FS USE_USB_HS GD32H73X_75X
  c include: ..\inc;..\fat_fs\inc;..\..\..\..\Firmware\CMSIS;..\..\..\..\Firmware\CMSIS\GD\GD32H73x_75x\Include;..\..\..\..\Firmware\GD32H73x_75x_standard_peripheral\Include;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\driver\Include;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\device\core\Include;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\host\core\Include;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\device\class\hid\Include;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\host\class\msc\Include;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\common;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\class\hid;..\..\..\..\Firmware\GD32H73x_75x_usbhs_library\ustd\class\msc;..\..\..\..\Utilities;..\..\..\..\Utilities\LCD_common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../src/: app.c custom_hid_itf.c gd32h73x_75x_it.c gd32h73x_75x_usb_hw.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32h73x_75x.c
  group GD32H73x_75x_Peripherals
    ../../../../Firmware/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_ctc.c gd32h73x_75x_exti.c gd32h73x_75x_gpio.c gd32h73x_75x_misc.c gd32h73x_75x_pmu.c gd32h73x_75x_rcu.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_usart.c gd32h73x_75x_exmc.c gd32h73x_75x_tli.c
  group GD32H73x_75x_EVAL
    ../../../../Utilities/: gd32h759i_eval.c gd32h759i_eval_exmc_sdram.c gd32h759i_lcd_eval.c
    ../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/ARM/: startup_gd32h73x_75x.s
  group USB_Driver
    ../../../../Firmware/GD32H73x_75x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c drv_usb_host.c drv_usbh_int.c
  group USB_Device
    ../../../../Firmware/GD32H73x_75x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Host
    ../../../../Firmware/GD32H73x_75x_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USBD_Class
    ../../../../Firmware/GD32H73x_75x_usbhs_library/device/class/hid/Source/: custom_hid_core.c
  group USBH_Class
    ../../../../Firmware/GD32H73x_75x_usbhs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FatFs
    ../fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
