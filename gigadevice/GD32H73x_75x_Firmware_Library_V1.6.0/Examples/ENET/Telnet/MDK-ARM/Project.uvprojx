# Keil uVision project Project.uvprojx, settings and files
target GD32H73x_75x_ENET (6160000::V6.16::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.5.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32H73X_75X
  c include: ..\..\..\..\Utilities;..\inc;..\lwip-2.2.1\src\include;..\lwip-2.2.1\src\include\lwip;..\lwip-2.2.1\src\include\netif;..\lwip-2.2.1\port\GD32H73x_75x;..\lwip-2.2.1\port\GD32H73x_75x\Basic;..\..\..\..\Firmware\GD32H73x_75x_standard_peripheral\Include;..\..\..\..\Firmware\CMSIS\GD\GD32H73x_75x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../src/: main.c netconf.c hello_gigadevice.c gd32h73x_75x_it.c gd32h73x_75x_enet_eval.c gd32h73x_75x_enet_ext.c
  group GD32H73x_75x_Peripherals
    ../../../../Firmware/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_adc.c gd32h73x_75x_can.c gd32h73x_75x_cau.c gd32h73x_75x_cau_aes.c gd32h73x_75x_cau_des.c gd32h73x_75x_cau_tdes.c gd32h73x_75x_cmp.c gd32h73x_75x_cpdm.c gd32h73x_75x_crc.c gd32h73x_75x_ctc.c gd32h73x_75x_dac.c gd32h73x_75x_dbg.c gd32h73x_75x_dci.c gd32h73x_75x_dma.c gd32h73x_75x_edout.c gd32h73x_75x_efuse.c gd32h73x_75x_enet.c gd32h73x_75x_exmc.c gd32h73x_75x_exti.c gd32h73x_75x_fac.c gd32h73x_75x_fmc.c gd32h73x_75x_fwdgt.c gd32h73x_75x_gpio.c gd32h73x_75x_hau.c gd32h73x_75x_hau_sha_md5.c gd32h73x_75x_hpdf.c gd32h73x_75x_hwsem.c gd32h73x_75x_i2c.c gd32h73x_75x_ipa.c gd32h73x_75x_lpdts.c gd32h73x_75x_mdio.c gd32h73x_75x_mdma.c gd32h73x_75x_misc.c gd32h73x_75x_ospi.c gd32h73x_75x_ospim.c gd32h73x_75x_pmu.c gd32h73x_75x_rameccmu.c gd32h73x_75x_rcu.c gd32h73x_75x_rspdif.c gd32h73x_75x_rtc.c gd32h73x_75x_rtdec.c gd32h73x_75x_sai.c gd32h73x_75x_sdio.c gd32h73x_75x_spi.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_tli.c gd32h73x_75x_tmu.c gd32h73x_75x_trigsel.c gd32h73x_75x_trng.c gd32h73x_75x_usart.c gd32h73x_75x_vref.c gd32h73x_75x_wwdgt.c
  group Lwip
    ../lwip-2.2.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-2.2.1/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.2.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.2.1/src/netif/: ethernet.c
  group Lwip_port
    ../lwip-2.2.1/port/GD32H73x_75x/Basic/: ethernetif.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/: system_gd32h73x_75x.c
    ../../../../Firmware/CMSIS/GD/GD32H73x_75x/Source/ARM/: startup_gd32h73x_75x.s
  group GD32H73x_75x_EVAL
    ../../../../Utilities/: gd32h759i_eval.c
  group Doc
    ../src/: readme.txt
software components: CMSIS:CORE 5.2.0
